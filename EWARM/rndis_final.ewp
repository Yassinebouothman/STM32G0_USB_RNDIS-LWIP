# IAR project rndis_final.ewp, settings and files
configuration rndis_final (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0B1RE ST STM32G0B1RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G0B1xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_RNDIS\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\rndis\App; ..\rndis\Target; ..\Middlewares\Third_Party\LwIP\src\include; ..\Middlewares\Third_Party\LwIP\system; ..\LwIP\Target
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rndis_final.hex
  ILINK.IlinkOutputFile: rndis_final.out
  ILINK.IlinkIcfFile: stm32g0b1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: gpio.c main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/User/lwip/Target
    ../LwIP/Target/: ethernetif.c
  group Application/User/rndis/App
    ../rndis/App/: usb_device.c usbd_cdc_rndis_if.c usbd_desc.c
  group Application/User/rndis/Target
    ../rndis/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_usb.c
  group Middlewares/Lwip_lib/api
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Lwip_lib/core
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Lwip_lib/netif
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group Middlewares/Lwip_lib/system
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/usb_device_lib/cdc_rndis
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC_RNDIS/Src/: usbd_cdc_rndis.c
  group Middlewares/usb_device_lib/core
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
